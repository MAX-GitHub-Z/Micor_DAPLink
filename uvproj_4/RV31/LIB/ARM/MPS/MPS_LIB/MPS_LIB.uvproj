# Keil uVision project MPS_LIB.uvproj, settings and files
target Cortex-M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: MPS_CM0 (library)
  AfterMake: cmd.exe /C copy .\Output\MPS_CM0.LIB ..\MPS_CM0.LIB
  c flags: Optim=4 OneElfS=1
  c define: CM0
  c include: ..\..\..\..\..\INC\ARM
  group Library Source
    ./: charlcd.c
target Cortex-M3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MPS_CM3 (library)
  AfterMake: cmd.exe /C copy .\Output\MPS_CM3.LIB ..\MPS_CM3.LIB
  c flags: Optim=4 OneElfS=1
  c define: CM3
  c include: ..\..\..\..\..\INC\ARM
