# Keil uVision project Micor_DAPLink.uvprojx, settings and files
target STM32F103ZET6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Micor_DAPLink +hex
  AfterMake: E:\keil5\ARM\ARMCC\bin\fromelf.exe --bin -o ./build/Micor_DAPLink.bin ./build/Micor_DAPLink.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_HD BLUEPILL SWO_PB7
  c include: .\CMSIS-DAP;.\USB;.\User;.\Driver\STM32F10x_ARM_Driver;.\Driver\STM32F10x_StdPeriph_Driver\inc;.\CMSIS-DAP\cmsis-core;.\uvproj_4\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --info=summarysizes --info=unused --info=totals
  group User
    ./User/: main.c stm32f10x_conf.h system_stm32f10x.c startup_stm32f10x_md.s
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP_config.h DAP.h DAP.c JTAG_DP.c SW_DP.c SWO.c
  group Driver
    ./Driver/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group USART
    ./Driver/STM32F10x_ARM_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c USART_STM32F10x.c
  group USB
    ./USB/: usb_config.c usbd_STM32F103.c usbd_user_hid.c usbd_user_cdc_acm.c USB_CM3.lib
software components: CMSIS:CORE 5.6.0
